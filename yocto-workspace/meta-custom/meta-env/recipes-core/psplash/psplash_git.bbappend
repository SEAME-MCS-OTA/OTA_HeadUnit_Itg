# FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
#
# SPLASH_IMAGES = "file://Ferrari_Seame_bootimg.png;outsuffix=default"
#
# SRC_URI += "file://Ferrari_Seame_bootimg.png"
#
# # DES Cockpit branding
# ALTERNATIVE_PRIORITY = "200"
